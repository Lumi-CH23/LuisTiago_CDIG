options:
  parameters:
    generate_options: qt_gui
    id: Cdig1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: current_freq
  id: variable
  parameters:
    value: '2412000000'
  states: {}
- name: freq_index
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_list
  id: variable
  parameters:
    value: '[2412e6,2437e6,2462e6]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: thr
  id: variable
  parameters:
    value: '0.560'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65000'
    rate: '1e-2'
    reference: '0.7'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '320'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/c/Users/lumic/Wifi_Project_Baseband_recordings/Wifi_Project_Baseband_recordings/Sample2_20MHz_Channel6.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /mnt/c/Users/lumic/Wifi_Project_Baseband_recordings/Wifi_Project_Baseband_recordings/Sample2_20MHz_Channel6.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_probe_signal_x_1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_1_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '0.7'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lts_taps
    type: ccc
  states: {state: disabled}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.LS
    bw: 20e6
    debug: 'False'
    freq: current_freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_sync_long_1
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '320'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: thr
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: current_freq
    gain1: '''manual'''
    manual_gain1: '60'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '5555'
    type: UDP_CLIENT
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.98'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.95'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.95'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.95'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import threading
      import time

      def wifi_sweep_thread():
          """
          Thread de varrimento automático de canais WiFi.
          Usa a variável 'tb' (top block) que o GNU Radio passa a este snippet.
          """

          while True:
              # 1) Ler lista de frequências e índice atual
              freq_list = tb.freq_list
              idx = int(tb.freq_index)

              # 2) Frequência atual
              freq = freq_list[idx]

              # Atualizar current_freq (usada pelo Pluto LO Frequency)
              tb.set_variable_by_id("current_freq", freq)

              # 3) Medir potência com o Probe Signal
              try:
                  power = tb.blocks_probe_signal_x_0.level()
              except Exception as e:
                  print("Erro ao ler probe:", e)
                  power = 0.0

              # 4) Threshold para detetar WiFi
              thr = tb.thr

              if power > thr:
                  print(f"[+] WiFi DETETADO em {freq/1e9:.3f} GHz  Power={power:.4f}")
              else:
                  print(f"--- Sem WiFi em {freq/1e9:.3f} GHz  Power={power:.4f}")

              # 5) Próximo índice da lista
              idx = (idx + 1) % len(freq_list)
              tb.set_variable_by_id("freq_index", idx)

              # 6) Esperar um bocadinho antes de mudar outra vez
              time.sleep(0.3)


      # Criar e arrancar a thread
      t = threading.Thread(target=wifi_sweep_thread)
      t.daemon = True     # fecha quando o flowgraph fecha
      t.start()
    section: main_after_init
  states: {state: disabled}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      import threading
      import time
      import math

      # apanhar o objeto do flowgraph (top block)
      _locals = locals()
      tb = list(_locals.values())[0] if _locals else None


      # ---------------------------------------------------------
      # THREAD 1: SWEEP com pausa de 10 segundos ao detectar WiFi
      # ---------------------------------------------------------

      def wifi_sweep_thread():
          """
          Sweep automático das frequências em freq_list.
          Quando detecta WiFi (power > limiar), fica 10 segundos parado.
          Depois continua o sweep normalmente.
          """

          hold_no_wifi = 0.3        # tempo entre canais quando não há WiFi
          wifi_power_thr = 0.00015  # limiar de potência para dizer "há Wi-Fi"
          pause_time = 10.0         # pausa quando detecta WiFi

          while True:
              try:
                  freq_list = tb.freq_list
                  idx = int(tb.freq_index)
              except Exception as e:
                  print("Erro a ler freq_list / freq_index:", e)
                  time.sleep(0.5)
                  continue

              if not freq_list:
                  time.sleep(0.5)
                  continue

              freq = freq_list[idx]

              # mudar LO do Pluto
              try:
                  tb.set_current_freq(freq)
              except Exception as e:
                  print("Erro em set_current_freq:", e)

              # ler potência global (probe do Complex→Mag²)
              try:
                  power = tb.blocks_probe_signal_x_1.level()
              except:
                  power = 0.0

              print(f"[SWEEP] freq={freq/1e9:.3f} GHz  power={power:.6f}")

              # --------------------------------------
              # DETECTOU Wi-Fi ?
              # --------------------------------------
              if power > wifi_power_thr:
                  print(f"[INFO] WiFi detectada em {freq/1e9:.3f} GHz → pausa {pause_time}s")
                  time.sleep(pause_time)

                  # depois de esperar, avança para o próximo canal
                  idx = (idx + 1) % len(freq_list)
                  try:
                      tb.set_freq_index(idx)
                  except:
                      pass

                  continue

              # --------------------------------------
              # Não há Wi-Fi → avançar para o próximo
              # --------------------------------------
              idx = (idx + 1) % len(freq_list)
              try:
                  tb.set_freq_index(idx)
              except:
                  pass

              time.sleep(hold_no_wifi)



      # ---------------------------------------------------------
      # THREAD 2: THRESHOLD AUTOMÁTICO DO SYNC SHORT
      # ---------------------------------------------------------

      def auto_threshold_thread():
          """
          Calcula limiar adaptativo para o WiFi Sync Short usando média+desvio.
          """

          alpha = 0.02
          k = 3.0

          mean = 0.0
          var  = 0.0

          while True:
              try:
                  x = tb.blocks_probe_signal_x_1_0.level()
              except:
                  x = 0.0

              # média e variância exponencial
              mean = (1 - alpha)*mean + alpha*x
              diff = x - mean
              var  = (1 - alpha)*var  + alpha*(diff*diff)
              std  = math.sqrt(max(var, 1e-12))

              new_thr = mean + k*std

              try:
                  tb.set_thr(new_thr)
              except:
                  pass

              time.sleep(0.02)



      # ---------------------------------------------------------
      # Lançar as threads
      # ---------------------------------------------------------

      t1 = threading.Thread(target=wifi_sweep_thread)
      t1.daemon = True
      t1.start()

      t2 = threading.Thread(target=auto_threshold_thread)
      t2.daemon = True
      t2.start()
    section: main_after_init
  states: {state: disabled}
- name: snippet_2
  id: snippet
  parameters:
    code: |-
      import threading
      import time
      import math

      # apanhar o objeto do flowgraph (top block)
      _locals = locals()
      tb = list(_locals.values())[0] if _locals else None


      # ---------------------------------------------------------
      # THREAD 1: SWEEP COM LIMIAR SIMPLES EM 2.4 GHz
      # ---------------------------------------------------------

      def wifi_sweep_thread():
          """
          Sweep automático das frequências em freq_list.

          - Apenas procura Wi-Fi REAL em 2.4 GHz.
          - Usa um limiar fixo de potência (ajustado aos teus valores).
          - Mostra 'thr' a cada sweep.
          - Quando encontra Wi-Fi, faz pausa para decodificação.
          """

          hold_no_wifi   = 0.25
          pause_24ghz    = 30.0
          wifi_thr_24ghz = 8e-5     # ajustado à tua potência (~1e-4)

          while True:
              try:
                  freq_list = tb.freq_list
                  idx = int(tb.freq_index)
              except Exception as e:
                  print("Erro a ler freq_list / freq_index:", e)
                  time.sleep(0.5)
                  continue

              if not freq_list:
                  time.sleep(0.5)
                  continue

              freq = freq_list[idx]

              # mudar LO do Pluto
              try:
                  tb.set_current_freq(freq)
              except Exception as e:
                  print("Erro em set_current_freq:", e)

              # ler potência
              try:
                  power = tb.blocks_probe_signal_x_1.level()
              except:
                  power = 0.0

              # ler limiar atual do Sync Short
              try:
                  thr = tb.thr
              except:
                  thr = -1.0

              # linha completa de debug
              print(f"[SWEEP] freq={freq/1e9:.3f} GHz  power={power:.6f}  thr={thr:.6f}")

              # banda 2.4 GHz
              is_24 = 2.3e9 <= freq <= 2.5e9

              # DETEÇÃO DE WiFi
              if is_24 and power > wifi_thr_24ghz:
                  print(f"[INFO] WiFi detectada em {freq/1e9:.3f} GHz | power={power:.6f}  thr={thr:.6f} → pausa {pause_24ghz:.1f}s")
                  time.sleep(pause_24ghz)

                  # avança o índice
                  idx = (idx + 1) % len(freq_list)
                  try:
                      tb.set_freq_index(idx)
                  except:
                      pass

                  continue

              # avançar para próximo canal
              idx = (idx + 1) % len(freq_list)
              try:
                  tb.set_freq_index(idx)
              except:
                  pass

              time.sleep(hold_no_wifi)



      # ---------------------------------------------------------
      # THREAD 2: THRESHOLD AUTOMÁTICO DO SYNC SHORT
      # ---------------------------------------------------------

      def auto_threshold_thread():
          """
          Calcula limiar adaptativo para o WiFi Sync Short usando média+desvio.
          """

          alpha = 0.02
          k = 3.0

          mean = 0.0
          var  = 0.0

          while True:
              try:
                  x = tb.blocks_probe_signal_x_1_0.level()
              except:
                  x = 0.0

              mean = (1.0 - alpha) * mean + alpha * x
              diff = x - mean
              var = (1.0 - alpha) * var + alpha * (diff * diff)
              std = math.sqrt(max(var, 1e-12))

              new_thr = mean + k * std

              try:
                  tb.set_thr(new_thr)
              except:
                  pass

              time.sleep(0.02)



      # ---------------------------------------------------------
      # Lançar as threads
      # ---------------------------------------------------------

      t1 = threading.Thread(target=wifi_sweep_thread)
      t1.daemon = True
      t1.start()

      t2 = threading.Thread(target=auto_threshold_thread)
      t2.daemon = True
      t2.start()
    section: main_after_init
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [analog_agc_xx_0, '0', blocks_delay_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_probe_signal_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_1, '1']
- [blocks_divide_xx_0, '0', blocks_probe_signal_x_1_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', fir_filter_xxx_0_0_0, '0']
- [blocks_file_source_1, '0', blocks_delay_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, '0', blocks_delay_0, '0']
- [epy_block_0, '0', blocks_multiply_xx_0, '1']
- [epy_block_0, '0', blocks_probe_signal_x_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_divide_xx_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0_0, '0', ieee802_11_sync_short_0, '1']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_parse_mac_0, out, network_socket_pdu_0, pdus]
- [ieee802_11_sync_long_1, '0', blocks_complex_to_mag_1, '0']
- [ieee802_11_sync_long_1, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_1, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '1']
- [iio_pluto_source_0, '0', epy_block_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0_0_1, '0']

metadata:
  file_format: 1
