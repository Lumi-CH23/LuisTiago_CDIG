options:
  parameters:
    generate_options: qt_gui
    id: Cdig1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: current_freq
  id: variable
  parameters:
    value: '2412000000'
  states: {}
- name: freq_index
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq_list
  id: variable
  parameters:
    value: '[2412e6, 2437e6, 2462e6, 2472e6, 5180e6, 5200e6, 5220e6, 5240e6,5260e6, 5280e6, 5300e6, 5320e6, 5500e6, 5520e6, 5540e6, 5560e6, 5700e6, 5745e6, 5785e6, 5825e6]'
  states: {}
- name: k_thr
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.05'
    stop: '1'
    value: '0.560'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: thr
  id: variable
  parameters:
    value: '0.560'
  states: {}
- name: thr_0
  id: variable
  parameters:
    value: '0.003'
  states: {state: disabled}
- name: window_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65000'
    rate: '1e-2'
    reference: '0.7'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '320'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/c/Users/lumic/Wifi_Project_Baseband_recordings/Wifi_Project_Baseband_recordings/Sample2_20MHz_Channel6.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /mnt/c/Users/lumic/Wifi_Project_Baseband_recordings/Wifi_Project_Baseband_recordings/Sample2_20MHz_Channel6.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_probe_signal_x_1
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_signal_x_1_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '0.7'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1]*window_size'
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lts_taps
    type: ccc
  states: {state: disabled}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.LS
    bw: 20e6
    debug: 'False'
    freq: '2412000000'
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_sync_long_1
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: '320'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: thr
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: current_freq
    gain1: '''manual'''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '5555'
    type: UDP_CLIENT
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.98'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.95'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.95'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.000005'
    tr_level: '0.95'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import threading
      import time

      def wifi_sweep_thread():
          """
          Thread de varrimento automático de canais WiFi.
          Usa a variável 'tb' (top block) que o GNU Radio passa a este snippet.
          """

          while True:
              # 1) Ler lista de frequências e índice atual
              freq_list = tb.freq_list
              idx = int(tb.freq_index)

              # 2) Frequência atual
              freq = freq_list[idx]

              # Atualizar current_freq (usada pelo Pluto LO Frequency)
              tb.set_variable_by_id("current_freq", freq)

              # 3) Medir potência com o Probe Signal
              try:
                  power = tb.blocks_probe_signal_x_0.level()
              except Exception as e:
                  print("Erro ao ler probe:", e)
                  power = 0.0

              # 4) Threshold para detetar WiFi
              thr = tb.thr

              if power > thr:
                  print(f"[+] WiFi DETETADO em {freq/1e9:.3f} GHz  Power={power:.4f}")
              else:
                  print(f"--- Sem WiFi em {freq/1e9:.3f} GHz  Power={power:.4f}")

              # 5) Próximo índice da lista
              idx = (idx + 1) % len(freq_list)
              tb.set_variable_by_id("freq_index", idx)

              # 6) Esperar um bocadinho antes de mudar outra vez
              time.sleep(0.3)


      # Criar e arrancar a thread
      t = threading.Thread(target=wifi_sweep_thread)
      t.daemon = True     # fecha quando o flowgraph fecha
      t.start()
    section: main_after_init
  states: {state: disabled}
- name: snippet_1
  id: snippet
  parameters:
    code: |-
      import threading
      import time
      import math

      # apanhar o objeto do flowgraph (top block) passado a este snippet
      _locals = locals()
      tb = list(_locals.values())[0] if _locals else None

      # -------------------------
      # THREAD 1: Sweep de Frequências
      # -------------------------

      def wifi_sweep_thread():
          """
          Varrimento automático da lista freq_list.
          Atualiza current_freq (LO do Pluto) e imprime a potência média.
          """

          while True:
              try:
                  freq_list = tb.freq_list
                  idx = int(tb.freq_index)
              except Exception as e:
                  print("Erro a ler variáveis de frequência:", e)
                  time.sleep(0.5)
                  continue

              if not freq_list:
                  time.sleep(0.5)
                  continue

              # frequência atual
              freq = freq_list[idx]

              # atualizar variável usada no Pluto LO
              try:
                  tb.set_current_freq(freq)
              except Exception as e:
                  print("Erro em set_current_freq:", e)

              # medir potência global (Probe ligado ao Complex to Mag^2)
              try:
                  power = tb.blocks_probe_signal_x_1.level()
              except Exception as e:
                  print("Erro a ler probe de potência:", e)
                  power = 0.0

              print(f"[SWEEP] freq={freq/1e9:.3f} GHz  power={power:.4f}")

              # próximo canal
              idx = (idx + 1) % len(freq_list)
              try:
                  tb.set_freq_index(idx)
              except Exception as e:
                  print("Erro em set_freq_index:", e)

              time.sleep(0.3)


      # -------------------------
      # THREAD 2: Threshold Automático do Sync Short
      # -------------------------

      def auto_threshold_thread():
          """
          Calcula limiar 'thr' adaptativo para o WiFi Sync Short,
          usando a saída do Divide (probe blocks_probe_signal_x_1_0).
          thr = média + k * desvio_padrão (estimados exponencialmente).
          """

          alpha = 0.02   # rapidez de adaptação
          k = 3.0        # quantos desvios acima da média

          mean = 0.0
          var = 0.0

          while True:
              try:
                  x = tb.blocks_probe_signal_x_1_0.level()
              except Exception as e:
                  print("Erro a ler probe_corr:", e)
                  x = 0.0

              # média e variância exponencial
              mean = (1.0 - alpha) * mean + alpha * x
              diff = x - mean
              var = (1.0 - alpha) * var + alpha * (diff * diff)
              std = math.sqrt(max(var, 1e-12))

              new_thr = mean + k * std

              try:
                  tb.set_thr(new_thr)
              except Exception as e:
                  print("Erro em set_thr:", e)

              # debug opcional:
              # print(f"[THR] mean={mean:.4f} std={std:.4f} thr={new_thr:.4f}")

              time.sleep(0.02)


      # -------------------------
      # Arrancar as duas threads
      # -------------------------

      t1 = threading.Thread(target=wifi_sweep_thread)
      t1.daemon = True
      t1.start()

      t2 = threading.Thread(target=auto_threshold_thread)
      t2.daemon = True
      t2.start()
      def wifi_sweep_thread():
          """
          Varrimento automático da lista freq_list.
          Fica mais tempo parado na frequência quando deteta Wi-Fi,
          para permitir apanhar mais frames / bits.
          """

          # tempos de espera (em segundos)
          hold_no_wifi = 0.3   # quando não há Wi-Fi
          hold_wifi    = 2.0   # quando há Wi-Fi (fica parado aqui)

          # limiar de potência para dizer "há Wi-Fi"
          wifi_power_thr = 0.0005   # podes afinar mais tarde

          while True:
              try:
                  freq_list = tb.freq_list
                  idx = int(tb.freq_index)
              except Exception as e:
                  print("Erro a ler variáveis de frequência:", e)
                  time.sleep(0.5)
                  continue

              if not freq_list:
                  time.sleep(0.5)
                  continue

              # frequência atual
              freq = freq_list[idx]

              # atualizar variável usada no Pluto LO
              try:
                  tb.set_current_freq(freq)
              except Exception as e:
                  print("Erro em set_current_freq:", e)

              # medir potência global (Probe ligado ao Complex to Mag^2)
              try:
                  power = tb.blocks_probe_signal_x_1.level()
              except Exception as e:
                  print("Erro a ler probe de potência:", e)
                  power = 0.0

              print(f"[SWEEP] freq={freq/1e9:.3f} GHz  power={power:.4f}")

              # decidir quanto tempo ficar aqui e se mudamos de canal
              if power > wifi_power_thr:
                  # Há Wi-Fi → NÃO muda de canal, só espera mais tempo
                  time.sleep(hold_wifi)
              else:
                  # Não há Wi-Fi → passa já ao próximo canal
                  idx = (idx + 1) % len(freq_list)
                  try:
                      tb.set_freq_index(idx)
                  except Exception as e:
                      print("Erro em set_freq_index:", e)

                  time.sleep(hold_no_wifi)
    section: main_after_init
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [analog_agc_xx_0, '0', blocks_delay_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_probe_signal_x_1, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_long_1, '1']
- [blocks_divide_xx_0, '0', blocks_probe_signal_x_1_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', fir_filter_xxx_0_0_0, '0']
- [blocks_file_source_1, '0', blocks_delay_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', blocks_complex_to_mag_squared_0, '0']
- [epy_block_0, '0', blocks_delay_0, '0']
- [epy_block_0, '0', blocks_multiply_xx_0, '1']
- [epy_block_0, '0', blocks_probe_signal_x_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [fir_filter_xxx_0, '0', blocks_divide_xx_0, '1']
- [fir_filter_xxx_0_0, '0', blocks_complex_to_mag_0, '0']
- [fir_filter_xxx_0_0, '0', ieee802_11_sync_short_0, '1']
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_parse_mac_0, out, network_socket_pdu_0, pdus]
- [ieee802_11_sync_long_1, '0', blocks_complex_to_mag_1, '0']
- [ieee802_11_sync_long_1, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_1, '0']
- [iio_pluto_source_0, '0', analog_agc_xx_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', blocks_delay_0, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '1']
- [iio_pluto_source_0, '0', epy_block_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0_0_1, '0']

metadata:
  file_format: 1
